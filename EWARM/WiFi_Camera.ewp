# IAR project WiFi_Camera.ewp, settings and files
configuration WiFi_Camera (ARM, debug)
  General.OGChipSelectEditMenu: STM32F437ZI ST STM32F437ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F437xx; EN_DEBUG; nPRINT_JPG_DATA; OV2640
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ..\Application\Include; ../Middlewares/Third_Party/FatFs/src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Inc
  OBJCOPY.OOCOutputFile: WiFi_Camera.bin
  postbuild: python ..\script\generate_v3.py $PROJ_DIR$
  ILINK.IlinkOutputFile: WiFi_Camera.out
  ILINK.IlinkIcfFile: stm32f437xx_flash_offset.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f437xx.s
  group Application/Peripherial/Header
    ../Application/Include/: delay.h lcd_driver.h memory.h ov7670.h ov7670config.h sccb.h util.h
  group Application/Peripherial/Source
    ../Application/Source/: delay.c lcd_driver.c memory.c ov7670.c sccb.c util.c
  group Application/Task/Header
    ../Application/Include/: camera_task.h client_task.h client_task_demo.h debug_task.h display_task.h global_config.h motor_task.h wifi_task.h wifi_task_demo.h
  group Application/Task/Source
    ../Application/Source/: camera_task.c client_task.c client_task_demo.c debug_task.c display_task.c motor_task.c wifi_task.c wifi_task_demo.c
  group Application/User
    ../Src/: main.c sd_diskio.c stm32f4xx_it.c bsp_driver_sd.c fatfs.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c freertos.c
  group Application/User/Header
    ../Inc/: FreeRTOSConfig.h main.h stm32f4xx_hal_conf.h stm32f4xx_it.h
  group Application/User/Source
    ../Src/: freertos.c main.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/FatFs
    ./: 
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
